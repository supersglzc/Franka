Commit message: Parameter tuning and cleaning

File: panda_gym/assets/franka_panda/panda_peg.urdf (robot description, URDF)
Before this commit: robot panda, 16 links, 15 joints
Joints:
- joint PegPosition: origin xyz=0 0.05 0 rpy=0 0 0 -> xyz=0 0.02 0 rpy=0 0 0
